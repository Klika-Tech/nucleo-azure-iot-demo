# Keil uVision project Project.uvprojx, settings and files
target STM32F401RE_Nucleo_IKS01A2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xx-Nucleo +hex
  AfterMake: fromelf --bin -o Azure_IKS01A2.bin
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USART_PRINT_MSG,EINVAL=-1,ENOMEM=EINVAL,USE_GENERICACCESSKEY_IOTHUB=0,DONT_USE_UPLOADTOBLOB=1,__NUCLEO_BUILD,__IKS01A2,NO_LOGGING=1
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW01M1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\iothub_client\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\serializer\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\agenttime_STM32Cube\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\httpapi_STM32Cube\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\iothub_client\sample\;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils\stdio_new;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils\ring_buffer;..\..\..\..\..\..\Drivers\BSP\Components\M24SR;..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\Components\iis2dh;..\..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x17fff
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c stm32f4xx_I2C.c
  group Azure/MDK-ARM
    ./: startup_stm32f401xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_qspi.c stm32f4xx_hal_usart.c
  group Main
    ../../Src/: stm32f4xx_it.c main.c console.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/M24SR/: lib_M24SR.c m24sr.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/iis2dh/: IIS2DH_Driver.c IIS2DH_Driver_HL.c
  group Drivers/BSP/X-NUCLEO-IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X-NUCLEO-NFC01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-NFC01A1/: drv_I2C_M24SR.c
  group Drivers/BSP/X-NUCLEO-IDW01M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW01M1/: stm32_spwf_wifi.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/: croutine.c event_groups.c queue.c tasks.c timers.c list_rt.c
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LibNDEF
    ../../../../../../Middlewares/ST/lib_NDEF/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_TagType4.c
  group Middlewares/STM32_SPWF01SA
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/: wifi_interface.c wifi_module.c
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/Utils/: event_buffer.c ring_buffer.c wifi_globals.c
  group azure-c-shared-utility
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-c-shared-utility/src/: base64.c buffer.c consolelogger.c crt_abstractions.c doublylinkedlist.c gb_stdio.c gb_time.c gballoc.c hmac.c hmacsha256.c httpapiex.c httpapiexsas.c httpheaders.c list.c map.c sastoken.c sha1.c sha224.c sha384-512.c string_tokenizer.c strings.c urlencode.c usha.c vector.c xio.c xlogging.c
  group azure-c-shared-utility/adapters
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-c-shared-utility/adapters/: agenttime_STM32Cube.c httpapi_STM32Cube.c lock_STM32Cube.c platform_STM32Cube.c threadapi_STM32Cube.c tickcounter_STM32Cube.c
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-c-shared-utility/adapters/agenttime_STM32Cube/: SynchronizationAgent.c timingSystem.c timingSystemNucleoF4.c
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-c-shared-utility/adapters/httpapi_STM32Cube/: InternetAdapter.c InternetInterface.c SocketMapping.c SocketOS.c
  group iothub_client
    ../../../../../../Middlewares/Third_Parties/AzureIOT/iothub_client/sample/: iothub_client_sample_http.c
    ../../../../../../Middlewares/Third_Parties/AzureIOT/iothub_client/src/: iothub_client.c iothub_client_ll.c iothub_message.c iothubtransport.c iothubtransporthttp.c version.c
  group Drivers/BSP/X-NUCLEO-IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
target STM32F401RE_Nucleo_IKS01A1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: STM32F4xx-Nucleo +hex
  AfterMake: fromelf --bin -o Azure_IKS01A1.bin
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USART_PRINT_MSG,EINVAL=-1,ENOMEM=EINVAL,USE_GENERICACCESSKEY_IOTHUB=0,DONT_USE_UPLOADTOBLOB=1,NO_LOGGING=1,__NUCLEO_BUILD
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW01M1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\iothub_client\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\serializer\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\agenttime_STM32Cube\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\httpapi_STM32Cube\inc;..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\iothub_client\sample\;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils\stdio_new;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils\ring_buffer;..\..\..\..\..\..\Drivers\BSP\Components\M24SR;..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc;..\..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x17fff
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
